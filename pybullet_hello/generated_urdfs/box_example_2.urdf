Commit message: cleaned code and added demonstration mode

File: pybullet_hello/generated_urdfs/box_example_2.urdf (robot description, URDF)
Before this commit: robot random_box, 1 links, 0 joints
Links:
- link box: geometry collision box size=0.05 0.05 0.05; visual box size=0.05 0.05 0.05
